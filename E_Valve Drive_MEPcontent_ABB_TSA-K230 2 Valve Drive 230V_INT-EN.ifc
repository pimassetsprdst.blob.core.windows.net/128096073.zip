Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-05-02T15:21:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 02 15:21:12 2018 * Host: B3ROBRAWR2779 * Database: C:\Users\LFI\AppData\Local\Temp\{510F2E29-DA8A-4741-B038-BA729BECEF11}\ifc * Database version: 5507 * Database creation date: Wed May 02 15:21:11 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed May 02 15:21:12 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 02 15:21:12 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: TSA-K230.2 Valve Drive 230V, E_Valve Drive_MEPcontent_ABB_TSA_INT-EN:TSA-K230.2 Valve Drive 230V:82099
In: Level 1
Type - Material: Color RGB 240-240-240, Color RGB 074-160-255
Type - Dimensions - Depth: 48.4 mm; Height: 52.2 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 180 deg; Width: 44.3 mm
Type - Electrical - Loads - Power: 0 W
Type - Electrical Engineering - Connection Voltage: 230 V
Type - Identity Data - App ID: EL_MODELPARTSYSTEM_MC; Article Description: TSA/K230.2 Thermoelctric Valve Drive, 230V; Article Type: TSA/K230.2; Category: EL_BUSSYSTEM_SENSOR; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: TSA/K230.2 Thermoelctric Valve Drive, 230V; EMCS Version: 3.0; ETIM Article Class: EC000792; Family Version: 11.14; GTIN: 4016779950671; Manufacturer: ABB; Manufacturer Art. No.: 2CDG120049R0011; Manufacturer URL: https://new.abb.com/products/2CDG120049R0011; MEPcontent Class: VALVE_DRIVE; Model: TSA/K230.2; OmniClass Number: 23.60.50.00; OmniClass Title: General Purpose Controls; Product Line: KNX - Heating, Ventilation and Air Conditioning - Thermoelectric Valve Drives; Revit Version: 2016; Type Name: TSA-K230.2 Valve Drive 230V; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Valve Drive_MEPcontent_ABB_TSA_INT-EN; No Drive Valve: No Valve Adapter; Valve Adapter VA Z10 1: Valve Adapter VA-Z10.1: Valve Adapter VA-Z10.1; Valve Adapter VA Z50 1: Valve Adapter VA-Z50.1: Valve Adapter VA-Z50.1; Valve Adapter VA Z78 1: Valve Adapter VA-Z78.1: Valve Adapter VA-Z78.1
Pset_BuildingElementProxyCommon - Reference: TSA-K230.2 Valve Drive 230V; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.00870748 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000885415 m3
Identity Data - Function Code: E6222BS; Mark: 1
Model Properties - Valve Adapter: No Valve Adapter
Other - Offset: 0 mm; Family: E_Valve Drive_MEPcontent_ABB_TSA_INT-EN: TSA-K230.2 Valve Drive 230V; Family and Type: E_Valve Drive_MEPcontent_ABB_TSA_INT-EN: TSA-K230.2 Valve Drive 230V; No Valve Adapter: yes; Type: E_Valve Drive_MEPcontent_ABB_TSA_INT-EN: TSA-K230.2 Valve Drive 230V; Type Id: E_Valve Drive_MEPcontent_ABB_TSA_INT-EN: TSA-K230.2 Valve Drive 230V; Valve Adapter VA Z10: no; Valve Adapter VA Z50: no; Valve Adapter VA Z78: no; Valve Adapter VA Z80: no; Valve Adapter VA Z80 1: Valve Adapter VA-Z80.1: Valve Adapter VA-Z80.1
Phasing - Phase Created: New Construction
